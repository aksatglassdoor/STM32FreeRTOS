# Keil uVision project STM32F4_FreeRTOS.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_FreeRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\CMSIS\Include;.\CMSIS\Lib\ARM;.\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\FreeRTOS;.\FreeRTOS\Source\include;.\FreeRTOS\startup;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
  group Startup
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/MemMang/: heap_1.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
